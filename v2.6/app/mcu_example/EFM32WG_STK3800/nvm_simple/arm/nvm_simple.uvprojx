# Keil uVision project nvm_simple.uvprojx, settings and files
target nvm_simple (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: nvm_simple
  AfterMake: fromelf.exe --bin --output obj\nvm_simple.bin obj\nvm_simple.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32WG_STK3800\config;..\..\..\..\..\platform\emdrv\nvm\inc;..\..\..\..\..\platform\emdrv\common\inc
  asm define: EFM32WG990F256 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ram_code.sct
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c bsp_stk_leds.c
  group Drivers
    ../../../../../platform/emdrv/nvm/src/: nvm.c nvm_hal.c
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_system.c em_msc.c em_lcd.c
  group Source
    ../: main.c nvm_config.c
