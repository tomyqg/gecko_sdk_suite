# IAR project burtc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32LG990F256 SiliconLaboratories EFM32LG990F256
  ICCARM.CCDefines: EFM32LG990F256; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32LG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32LG_STK3600\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32LG990F256; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: burtc.bin
  ILINK.IlinkOutputFile: burtc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32LG990F256; DEBUG_EFM
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/IAR/: startup_efm32lg.s
    ../../../../../platform/Device/SiliconLabs/EFM32LG/Source/: system_efm32lg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_lcd.c em_rmu.c em_burtc.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: segmentlcd.c
  group Source
    ../: main.c clock.c clock.h clockApp.c clockApp.h
