# IAR project micriumos_httpcloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; MBEDTLS_CONFIG_FILE="config-ssl-httpcloader.h"; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\platform\micrium_os; ..\..\..\..\..\platform\micrium_os\bsp\siliconlabs\generic\include; ..\cfg; ..; ..\..\..\..\..\util\third_party\mbedtls\include; ..\..\..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\include; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src; ..\..\..\..\..\platform\bootloader; ..\..\..\..\..\platform\bootloader\api
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: micriumos_httpcloader.bin
  ILINK.IlinkOutputFile: micriumos_httpcloader.out
  ILINK.IlinkIcfFile: ..\micriumos_httpcloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192; MBEDTLS_CONFIG_FILE="config-ssl-httpcloader.h"; DEBUG_EFM; RETARGET_VCOM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
    ../../../../../platform/micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c bsp_net_ether_gem.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_crypto.c em_emu.c em_gpio.c em_prs.c em_system.c em_usart.c
  group common
    ../../../../../platform/micrium_os/common/source/auth/: auth.c
    ../../../../../platform/micrium_os/common/source/clk/: clk.c clk_cmd.c
    ../../../../../platform/micrium_os/common/source/collections/: bitmap.c map.c slist.c
    ../../../../../platform/micrium_os/common/source/common/: common.c
    ../../../../../platform/micrium_os/common/source/kal/: kal_kernel.c
    ../../../../../platform/micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../../../platform/micrium_os/common/source/rtos/: rtos_err_str.c
    ../../../../../platform/micrium_os/common/source/platform_mgr/: platform_mgr.c
  group cpu
    ../../../../../platform/micrium_os/cpu/source/: cpu_core.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv7m_cpu_a.asm
    ../../../../../platform/micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
  group drivers
    ../../../../../platform/micrium_os/drivers/net/source/: net_drv_ether_gem.c net_drv_phy_generic.c
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group kernel
    ../../../../../platform/micrium_os/kernel/source/: os_core.c os_cfg_app.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../../platform/micrium_os/ports/source/iar/: armv7m_os_cpu_a.asm armv7m_os_cpu_c.c
  group net
    ../../../../../platform/micrium_os/net/source/tcpip/: net.c net_app.c net_arp.c net_ascii.c net_bsd.c net_buf.c net_cache.c net_conn.c net_ctr.c net_dad.c net_icmp.c net_icmpv4.c net_icmpv6.c net_if.c net_if_802x.c net_if_ether.c net_if_loopback.c net_if_wifi.c net_igmp.c net_ip.c net_ipv4.c net_ipv6.c net_mldp.c net_ndp.c net_sock.c net_stat.c net_task.c net_tcp.c net_tmr.c net_udp.c net_util.c net_wifi_mgr.c
    ../../../../../platform/micrium_os/net/source/sntp/: sntp_client.c
    ../../../../../platform/micrium_os/net/source/ssl_tls/: net_secure_mbedtls.c
    ../../../../../platform/micrium_os/net/source/util/: net_base64.c net_dict.c net_fs_port_native.c net_sha1.c net_svc_task.c
    ../../../../../platform/micrium_os/net/source/dhcp/: dhcp.c dhcp_client.c
    ../../../../../platform/micrium_os/net/source/dns/: dns_client.c dns_client_cache.c dns_client_req.c dns_client_task.c
  group http
    ../../../../../platform/micrium_os/net/source/http/: http.c http_dict.c
    ../../../../../platform/micrium_os/net/source/http/client/: http_client.c http_client_websock.c http_client_task.c http_client_mem.c http_client_req.c http_client_conn.c http_client_sock.c http_client_resp.c
  group bootloader
    ../../../../../platform/bootloader/api/: btl_interface_storage.c btl_interface.c
  group mbedTLS
    ../../../../../util/third_party/mbedtls/library/: sha1.c sha256.c sha512.c bignum.c ctr_drbg.c entropy.c entropy_poll.c error.c platform.c version.c version_features.c arc4.c base64.c blowfish.c ssl_cli.c ssl_srv.c ssl_ciphersuites.c gcm.c ccm.c camellia.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c hmac_drbg.c cipher.c cipher_wrap.c md.c md_wrap.c debug.c x509.c x509_crt.c oid.c pem.c des.c md5.c rsa.c rsa_internal.c ssl_tls.c pk.c pk_wrap.c pkparse.c pkcs5.c pkcs12.c asn1parse.c asn1write.c ripemd160.c
  group sl_crypto
    ../../../../../util/third_party/mbedtls/sl_crypto/src/: crypto_aes.c crypto_management.c shax.c trng.c crypto_sha.c crypto_ecp.c
  group Source
    ../: main.c btlapi.c ssl_certificates.c httpclient.c network.c application_properties.c bootloader-storage-internal-single-combined.s37
