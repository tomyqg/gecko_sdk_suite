# IAR project usbhloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG11B820F2048GL192 SiliconLaboratories EFM32GG11B820F2048GL192
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32GG11B820F2048GL192; DEBUG_EFM_USER; RETARGET_VCOM
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG11B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc; ..\..\..\..\..\util\third_party\fatfs\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3701A_EFM32GG11\config; ..\..\..\..\..\platform\bootloader; ..\..\..\..\..\platform\bootloader\api
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32GG11B820F2048GL192; DEBUG_EFM_USER; RETARGET_VCOM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usbhloader.bin
  ILINK.IlinkOutputFile: usbhloader.out
  ILINK.IlinkIcfFile: ..\usbhloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG11B820F2048GL192; DEBUG_EFM_USER; RETARGET_VCOM
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c bsp_bcc.c bsp_stk.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: msdh.c msdscsi.c msdbot.c retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/IAR/: startup_efm32gg11b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG11B/Source/: system_efm32gg11b.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbh.c em_usbhal.c em_usbhep.c em_usbhint.c em_usbtimer.c
  group FatFS
    ../../../../../util/third_party/fatfs/src/: msddiskio.c ff.c
  group bootloader
    ../../../../../platform/bootloader/api/: btl_interface_storage.c btl_interface.c
  group Source
    ../: main.c application_properties.c bootloader-storage-internal-single-combined.s37
