# IAR project blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32HG320F64R55 SiliconLaboratories EZR32HG320F64R55
  ICCARM.CCDefines: EZR32HG320F64R55; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EZR32HG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLWSTK6241A_EZR32HG\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EZR32HG320F64R55; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: blink.bin
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32HG320F64R55; DEBUG_EFM
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32HG/Source/IAR/: startup_ezr32hg.s
    ../../../../../platform/Device/SiliconLabs/EZR32HG/Source/: system_ezr32hg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_stk_leds.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_emu.c em_core.c em_gpio.c
  group Source
    ../: blink.c
