# IAR project rs232.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EZR32HG320F64R63 SiliconLaboratories EZR32HG320F64R63
  ICCARM.CCDefines: EZR32HG320F64R63; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EZR32HG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLWSTK6244A_EZR32HG\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EZR32HG320F64R63; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rs232.bin
  ILINK.IlinkOutputFile: rs232.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32HG320F64R63; DEBUG_EFM
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32HG/Source/IAR/: startup_ezr32hg.s
    ../../../../../platform/Device/SiliconLabs/EZR32HG/Source/: system_ezr32hg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_system.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ebi.c em_usart.c em_leuart.c
  group Source
    ../: main.c
