# Keil uVision project pdm-led.uvprojx, settings and files
target pdm-led (ARM-ADS)
  device: EFM32GG12B810F1024GM64 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: pdm-led
  AfterMake: fromelf.exe --bin --output obj\pdm-led.bin obj\pdm-led.axf
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: EFM32GG12B810F1024GM64 DEBUG_EFM
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLTB009A_EFM32GG12\config
  asm define: EFM32GG12B810F1024GM64 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/ARM/: startup_efm32gg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/: system_efm32gg12b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_timer.c em_usart.c
  group Source
    ../: pdm-led.c
