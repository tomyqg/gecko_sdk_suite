# Keil uVision project usbdpdmmic.uvprojx, settings and files
target usbdpdmmic (ARM-ADS)
  device: EFM32GG12B810F1024GM64 Silicon Labs
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0-0x1FFFFF) CLOCK(38400000) CPUTYPE("Cortex-M4") FPU2
  output: usbdpdmmic
  AfterMake: fromelf.exe --bin --output obj\usbdpdmmic.bin obj\usbdpdmmic.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c define: EFM32GG12B810F1024GM64 DEBUG_EFM_USER RETARGET_VCOM
  c misc: --diag_suppress=C1296
  c include: ..\;..;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG12B\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\platform\emdrv\common\inc;..\..\..\..\..\platform\emdrv\dmadrv\inc;..\..\..\..\..\platform\middleware\usb_gecko\inc;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLTB009A_EFM32GG12\config
  asm define: EFM32GG12B810F1024GM64 DEBUG_EFM_USER RETARGET_VCOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/ARM/: startup_efm32gg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG12B/Source/: system_efm32gg12b.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
    ../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_pdm.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group Source
    ../: main.c descriptors.c
