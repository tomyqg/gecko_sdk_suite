# IAR project ezradio_unmodulated_carrier.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EZR32WG330F256R63 SiliconLaboratories EZR32WG330F256R63
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EZR32WG330F256R63; SL_WSTK6224A; EZRADIO_DRIVER_EXTENDED_SUPPORT; EZRADIO_DRIVER_FULL_SUPPORT
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EZR32WG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLWSTK6224A_EZR32WG\config; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\dmadrv\inc; ..\..\..\..\..\platform\emdrv\gpiointerrupt\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..\..\..\..\..\platform\emdrv\spidrv\inc; ..\..\..\..\..\platform\emdrv\ustimer\inc; ..\..\..\..\..\platform\emdrv\ezradiodrv\common\inc; ..\..\..\..\..\platform\emdrv\ezradiodrv\common\inc\si4x6x; ..\..\..\..\..\platform\emdrv\ezradiodrv\si4463\inc; ..\..\..\..\..\platform\emdrv\ezradiodrv\plugins\inc; ..; ..\config; ..\config\RadioConfig
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ezradio_unmodulated_carrier.bin
  ILINK.IlinkOutputFile: ezradio_unmodulated_carrier.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EZR32WG330F256R63; SL_WSTK6224A; EZRADIO_DRIVER_EXTENDED_SUPPORT; EZRADIO_DRIVER_FULL_SUPPORT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32WG/Source/IAR/: startup_ezr32wg.s
    ../../../../../platform/Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c dmactrl.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group dmadrv
    ../../../../../platform/emdrv/dmadrv/src/: dmadrv.c
  group ezradiodrv
    ../../../../../platform/emdrv/ezradiodrv/common/src/: ezradio_api_lib.c ezradio_comm.c ezradio_hal.c
    ../../../../../platform/emdrv/ezradiodrv/common/src/si4x6x/: ezradio_api_lib_add.c
    ../../../../../platform/emdrv/ezradiodrv/plugins/src/: ezradio_plugin_manager.c ezradio_transmit_plugin.c ezradio_receive_plugin.c ezradio_crcerror_plugin.c ezradio_auto_ack_plugin.c ezradio_unmod_carrier_plugin.c ezradio_pn9_plugin.c ezradio_direct_transmit_plugin.c ezradio_direct_receive_plugin.c
  group gpiointerrupt
    ../../../../../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group rtcdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group spidrv
    ../../../../../platform/emdrv/spidrv/src/: spidrv.c
  group ustimer
    ../../../../../platform/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_dma.c em_gpio.c em_pcnt.c em_prs.c em_rtc.c em_system.c em_timer.c em_usart.c
  group Source
    ../: main.c
