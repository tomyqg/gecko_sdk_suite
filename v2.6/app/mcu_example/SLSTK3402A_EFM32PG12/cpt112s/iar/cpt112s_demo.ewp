# IAR project cpt112s_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\platform\middleware\glib\dmd; ..\..\..\..\..\platform\middleware\glib\dmd\ssd2119; ..\..\..\..\..\platform\middleware\glib\glib; ..; ..\Drivers; ..\img
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cpt112s_demo.bin
  ILINK.IlinkOutputFile: cpt112s_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: cpt112s_i2c.c display.c displayls013b7dh03.c displaypalemlib.c udelay.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_i2c.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group img
    ../img/: circle.xbm out_disable.xbm out_on.xbm out_off.xbm
  group Source
    ../: cpt112s_demo.c displayconfigapp.h
    ../Drivers/: render.c render.h lcd.c lcd.h
