# IAR project freertos_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\sleep\inc; ..\..\..\..\..\hardware\kit\common\bsp; ..; ..\..\..\..\..\util\third_party\freertos\Source\include; ..\..\..\..\..\util\third_party\freertos\Demo\Common\include; ..\..\..\..\..\util\third_party\freertos\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group BSP
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c bsp_stk_leds.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_rmu.c em_rtcc.c em_system.c
  group emdrv
    ../../../../../platform/emdrv/sleep/src/: sleep.c
  group FreeRTOS
    ../../../../../util/third_party/freertos/Source/: timers.c tasks.c queue.c list.c croutine.c event_groups.c
    ../../../../../util/third_party/freertos/Source/portable/MemMang/: heap_4.c
    ../../../../../util/third_party/freertos/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Demo
    ../../../../../util/third_party/freertos/Demo/Common/Minimal/: TimerDemo.c EventGroupsDemo.c TaskNotify.c blocktim.c GenQTest.c recmutex.c semtest.c flop.c dynamic.c StaticAllocation.c
    ../../../../../util/third_party/freertos/Demo/Common/SiliconLaboratories/: low_power_tick_management_RTCC.c
  group Source
    ../: main.c
    ../Full_Demo/: main_full.c RegTest_IAR.s
    ../Low_Power_Demo/: main_low_power.c
