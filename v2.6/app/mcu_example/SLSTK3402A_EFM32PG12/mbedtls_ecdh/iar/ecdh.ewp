# IAR project ecdh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="config-ecdh.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\dmadrv\inc; ..\..\..\..\..\platform\emdrv\dmadrv\config; ..\..\..\..\..\util\third_party\mbedtls\include; ..\..\..\..\..\util\third_party\mbedtls\include\mbedtls; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\include; ..\..\..\..\..\util\third_party\mbedtls\sl_crypto\src; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ecdh.bin
  ILINK.IlinkOutputFile: ecdh.out
  ILINK.IlinkIcfFile: ..\ecdh.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM; RETARGET_VCOM; MBEDTLS_CONFIG_FILE="config-ecdh.h"
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group cmsis
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group mbedtls
    ../../../../../util/third_party/mbedtls/library/: aes.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c cipher.c cipher_wrap.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_crypto.c em_cmu.c em_core.c em_emu.c em_gpio.c em_system.c em_usart.c
  group sl_crypto
    ../../../../../util/third_party/mbedtls/sl_crypto/src/: crypto_aes.c crypto_ecp.c crypto_management.c crypto_sha.c shax.c trng.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: retargetio.c retargetserial.c
  group test
    ../: main.c dummy_entropy.c
