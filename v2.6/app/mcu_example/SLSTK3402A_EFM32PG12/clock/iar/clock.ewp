# IAR project clock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; GLIB_NO_DEFAULT_FONT
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\platform\middleware\glib\glib; ..\..\..\..\..\platform\middleware\glib\dmd; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; GLIB_NO_DEFAULT_FONT
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: clock.bin
  ILINK.IlinkOutputFile: clock.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; GLIB_NO_DEFAULT_FONT
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c retargetio.c retargettextdisplay.c textdisplay.c udelay.c
  group glib
    ../../../../../platform/middleware/glib/dmd/display/: dmd_display.c
    ../../../../../platform/middleware/glib/glib/: glib.c glib_bitmap.c glib_circle.c glib_line.c glib_rectangle.c glib_string.c glib_font_narrow_6x8.c glib_font_number_16x20.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_pcnt.c em_prs.c em_rtcc.c em_system.c em_usart.c
  group Source
    ../: main.c analog_clock.c
