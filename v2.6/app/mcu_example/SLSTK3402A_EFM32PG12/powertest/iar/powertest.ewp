# IAR project powertest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG12B500F1024GL125 SiliconLaboratories EFM32PG12B500F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32PG12B\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\SLSTK3402A_EFM32PG12\config; ..\..\..\..\..\platform\emdrv\common\inc; ..\..\..\..\..\platform\emdrv\rtcdrv\inc; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32PG12B500F1024GL125; DEBUG_EFM
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: powertest.bin
  ILINK.IlinkOutputFile: powertest.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32PG12B500F1024GL125; DEBUG_EFM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/IAR/: startup_efm32pg12b.s
    ../../../../../platform/Device/SiliconLabs/EFM32PG12B/Source/: system_efm32pg12b.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_system.c em_rtcc.c em_wdog.c
  group emdrv
    ../../../../../platform/emdrv/rtcdrv/src/: rtcdriver.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_trace.c
  group Source
    ../: main.c
