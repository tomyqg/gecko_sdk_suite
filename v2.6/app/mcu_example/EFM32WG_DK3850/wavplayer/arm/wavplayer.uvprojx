# Keil uVision project wavplayer.uvprojx, settings and files
target wavplayer (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: wavplayer
  AfterMake: fromelf.exe --bin --output obj\wavplayer.bin obj\wavplayer.axf
  c flags: Optim=4 oTime=1
  c define: EFM32WG990F256 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\util\third_party\fatfs\inc;..\..\..\..\..\platform\middleware\glib
  asm define: EFM32WG990F256 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/ARM/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c microsd.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_dac.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group FatFS
    ../../../../../util/third_party/fatfs/src/: diskio.c ff.c
  group Source
    ../: wavplayer.c
