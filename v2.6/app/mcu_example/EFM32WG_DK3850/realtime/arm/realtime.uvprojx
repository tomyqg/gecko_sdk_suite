# Keil uVision project realtime.uvprojx, settings and files
target realtime (ARM-ADS)
  device: EFM32WG990F256 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: realtime
  AfterMake: fromelf.exe --bin --output obj\realtime.bin obj\realtime.axf
  c flags: Optim=4
  c define: EFM32WG990F256 DEBUG_EFM ENERGY_AWARE __HEAP_SIZE=0x800 __STACK_SIZE=0x1000
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\util\third_party\emwin\inc;..\..\..\..\..\platform\middleware\glib;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\common\drivers\emwin\Dk3750;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config
  asm define: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../: startup_arm.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_adc.c em_cmu.c em_core.c em_emu.c em_system.c em_rtc.c em_wdog.c em_gpio.c em_ebi.c em_usart.c em_i2c.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: calibrate.c eeprom.c i2cspm.c tftspi.c touch.c tftdirect.c
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group emwin
    ../../../../../hardware/kit/common/drivers/emwin/Dk3750/: GUIConf.c LCDConf.c GUI_X.c
  group Source
    ../: VSCREEN_RealTime.c
  group Libraries
    ../../../../../util/third_party/emwin/lib/: emwin_ARM_CM4F.lib
