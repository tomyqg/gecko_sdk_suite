# IAR project usbdtouch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256; DEBUG_EFM; __HEAP_SIZE=0x800; __STACK_SIZE=0x1000
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\platform\middleware\usb_gecko\inc; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config; ..\..\..\..\..\util\third_party\fatfs\inc; ..\..\..\..\..\platform\middleware\glib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usbdtouch.bin
  ILINK.IlinkOutputFile: usbdtouch.out
  ILINK.IlinkIcfFile: ..\usbdtouch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; DEBUG_EFM; __HEAP_SIZE=0x800; __STACK_SIZE=0x1000
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: calibrate.c eeprom.c i2cspm.c msdd.c norflash.c retargetio.c retargetserial.c tftspi.c touch.c tftdirect.c
  group graphics
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_core.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_system.c em_timer.c em_usart.c
  group emusb
    ../../../../../platform/middleware/usb_gecko/src/: em_usbd.c em_usbdch9.c em_usbhal.c em_usbdep.c em_usbdint.c em_usbtimer.c
  group fatfs
    ../../../../../util/third_party/fatfs/src/: ff.c
  group Source
    ../: main.c fnt16x28.c bitmap.c msddmedia.c descriptors.c
