# IAR project preamp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG990F256 SiliconLaboratories EFM32WG990F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG990F256; DEBUG_EFM; ARM_MATH_CM4; __FPU_PRESENT=1U
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32WG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\util\third_party\emwin\inc; ..\..\..\..\..\hardware\kit\common\drivers\emwin\Dk3750; ..\..\..\..\..\hardware\kit\EFM32WG_DK3850\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32WG990F256; DEBUG_EFM; ARM_MATH_CM4; __FPU_PRESENT=1U
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: preamp.bin
  ILINK.IlinkOutputFile: preamp.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\util\third_party\emwin\lib\emwin_IAR_CM4F.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG990F256; DEBUG_EFM; ARM_MATH_CM4; __FPU_PRESENT=1U
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../../../platform/Device/SiliconLabs/EFM32WG/Source/: system_efm32wg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_dk_leds.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: dmactrl.c
  group DSP
    ../../../../../platform/CMSIS/DSP_Lib/Source/FilteringFunctions/: arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_f32.c
  group emlib
    ../../../../../platform/emlib/src/: em_adc.c em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_core.c em_gpio.c em_prs.c em_system.c em_timer.c em_usart.c
  group Source
    ../: preamp.c preamp.h plot.c plot.h logo.c logo.h GUI_X.c LCDConf_mm.c
  group emwin
    ../../../../../hardware/kit/common/drivers/emwin/Dk3750/: GUIConf.c ssd2119.c
