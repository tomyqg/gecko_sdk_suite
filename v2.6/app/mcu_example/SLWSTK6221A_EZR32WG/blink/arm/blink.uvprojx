# Keil uVision project blink.uvprojx, settings and files
target blink (ARM-ADS)
  device: EZR32WG330F256R55 Silicon Labs
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(48000000) CPUTYPE("Cortex-M4") FPU2
  output: blink
  AfterMake: fromelf.exe --bin --output obj\blink.bin obj\blink.axf
  c flags: Optim=1
  c define: EZR32WG330F256R55 DEBUG_EFM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EZR32WG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\SLWSTK6221A_EZR32WG\config
  asm define: EZR32WG330F256R55 DEBUG_EFM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EZR32WG/Source/ARM/: startup_ezr32wg.s
    ../../../../../platform/Device/SiliconLabs/EZR32WG/Source/: system_ezr32wg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_core.c em_gpio.c em_system.c em_usart.c
  group Source
    ../: blink.c
