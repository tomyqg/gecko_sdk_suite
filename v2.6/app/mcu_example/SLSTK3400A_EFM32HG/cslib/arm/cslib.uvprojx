# Keil uVision project cslib.uvprojx, settings and files
target cslib (ARM-ADS)
  device: EFM32HG322F64 Silicon Labs
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: cslib
  AfterMake: fromelf.exe --bin --output obj\cslib.bin obj\cslib.axf
  c flags: Optim=1 oTime=1
  c define: EFM32HG322F64 DEBUG_EFM RETARGET_VCOM
  c misc: --c99
  c include: ..\;..\..\..\..\..\platform\CMSIS\Include;..\..\..\..\..\platform\Device\SiliconLabs\EFM32HG\Include;..\..\..\..\..\platform\emlib\inc;..\..\..\..\..\hardware\kit\common\bsp;..\..\..\..\..\hardware\kit\common\drivers;..\..\..\..\..\hardware\kit\SLSTK3400A_EFM32HG\config;..\..\..\..\..\platform\middleware\cslib\inc;..\..\..\..\..\platform\middleware\cslib\src\app;..\..\..\..\..\platform\middleware\cslib\src\device_ACMP;..\..\..\..\..\platform\middleware\cslib\src\serial;..\..\..\..\..\platform\middleware\cslib\src\config_ACMP
  asm define: EFM32HG322F64 DEBUG_EFM RETARGET_VCOM
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/ARM/: startup_efm32hg.s
    ../../../../../platform/Device/SiliconLabs/EFM32HG/Source/: system_efm32hg.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c
  group emlib
    ../../../../../platform/emlib/src/: em_acmp.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_core.c em_rtc.c em_system.c em_usart.c em_leuart.c
  group app
    ../../../../../platform/middleware/cslib/src/app/: cslib_config.c device_init.c
  group device_ACMP
    ../../../../../platform/middleware/cslib/src/device_ACMP/: hardware_config.c hardware_routines.c low_power_config.c
  group serial
    ../../../../../platform/middleware/cslib/src/serial/: comm_routines.c profiler_interface.c sensor_descriptors.c
    ../../../../../hardware/kit/common/drivers/: retargetserial.c retargetio.c
  group Source
    ../: main.c
  group Libraries
    ../../../../../platform/middleware/cslib/lib/: libCSLIB_M0_arm.lib
