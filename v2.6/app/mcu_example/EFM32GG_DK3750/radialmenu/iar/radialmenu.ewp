# IAR project radialmenu.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  ICCARM.CCDefines: EFM32GG990F1024; DEBUG_EFM; ENERGY_AWARE
  ICCARM.CCIncludePath2: ..\..\..\..\..\platform\CMSIS\Include; ..\..\..\..\..\platform\Device\SiliconLabs\EFM32GG\Include; ..\..\..\..\..\platform\emlib\inc; ..\..\..\..\..\util\third_party\emwin\inc; ..\..\..\..\..\platform\middleware\glib; ..\..\..\..\..\hardware\kit\common\drivers\emwin\Dk3750; ..\..\..\..\..\hardware\kit\common\drivers; ..\..\..\..\..\hardware\kit\common\bsp; ..\..\..\..\..\hardware\kit\EFM32GG_DK3750\config
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: EFM32GG990F1024; DEBUG_EFM; ENERGY_AWARE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: radialmenu.bin
  ILINK.IlinkOutputFile: radialmenu.out
  ILINK.IlinkIcfFile: ..\radialmenu.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\util\third_party\emwin\lib\emwin_IAR_CM3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32GG990F1024; DEBUG_EFM; ENERGY_AWARE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group CMSIS
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/IAR/: startup_efm32gg.s
    ../../../../../platform/Device/SiliconLabs/EFM32GG/Source/: system_efm32gg.c
  group emlib
    ../../../../../platform/emlib/src/: em_assert.c em_adc.c em_cmu.c em_core.c em_dma.c em_emu.c em_system.c em_rtc.c em_wdog.c em_gpio.c em_ebi.c em_usart.c em_i2c.c
  group bsp
    ../../../../../hardware/kit/common/bsp/: bsp_dk_3201.c bsp_trace.c
  group Drivers
    ../../../../../hardware/kit/common/drivers/: calibrate.c eeprom.c i2cspm.c tftspi.c touch.c tftdirect.c
    ../../../../../platform/middleware/glib/dmd/ssd2119/: dmd_ssd2119_direct.c
  group emwin
    ../: GUIConf.c LCDConf.c
    ../../../../../hardware/kit/common/drivers/emwin/Dk3750/: GUI_X.c
  group Source
    ../: WM_RadialMenu.c
